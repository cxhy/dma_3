<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\fet140_dma_01.ewp</path>
  </project>
  <batchBuild/>
</workspace>


